/*
   多个文件可以有多个根节点，但是最终编译的时候会合成唯一一个文件
*/

/ {
i2c0:	i2c@e0006000 {
			compatible = "i2c IBM device"; 
			reg = <0xe0006000 0x100>;
		};
};
